v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 90 -140 90 -130 {lab=+}
N 90 -70 90 -60 {lab=-}
C {symbols/cap_mim_2f0fF.sym} 90 -100 0 0 {name=C1
W=6.9e-6
L=6.9e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {lab_wire.sym} 90 -140 0 0 {name=p1 sig_type=std_logic lab=+
}
C {lab_wire.sym} 90 -60 2 1 {name=p2 sig_type=std_logic lab=-}
C {ipin.sym} 210 -180 0 0 {name=p3 lab=+
}
C {opin.sym} 200 -160 0 0 {name=p4 lab=-}
